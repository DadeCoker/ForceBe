# Keil uVision project BabyOS.uvprojx, settings and files
target BabyOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BabyOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\bos\core\inc\; ..\bos\drivers\inc\; ..\bos\hal\hal\inc; ..\bos\thirdparty\FlexibleButton; ..\bos\thirdparty\nr_micro_shell\inc; ..\bos\thirdparty\UGUI; ..\bos\thirdparty\CmBacktrace; ..\bos\thirdparty\qpn\inc; ..\bos\hal\utils\inc; ..\bos\modules\inc; ..\bos\config; ..\bos\algorithm\inc; ..\Examples\qpn
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BOS/Core
    ../bos/core/: b_core.c b_device.c b_os.c
  group BOS/Modules
    ../bos/modules/: b_mod_battery.c b_mod_button.c b_mod_error.c b_mod_event.c b_mod_fifo.c b_mod_gui.c b_mod_kv.c b_mod_log.c b_mod_lunar.c b_mod_menu.c b_mod_modbus.c b_mod_protocol.c b_mod_sda.c b_mod_sdb.c b_mod_shell.c b_mod_trace.c b_mod_utc.c b_mod_xm128.c b_mod_ymodem.c b_mod_heap.c b_mod_qpn.c b_mod_timer.c b_mod_param.c
  group BOS/Hal/hal
    ../bos/hal/hal/: b_hal.c b_hal_uart.c b_hal_gpio.c
  group BOS/Hal/utils
    ../bos/hal/utils/: b_util_delay.c
  group BOS/ThirdParty/nr_micro_shell
    ../bos/thirdparty/nr_micro_shell/src/: ansi.c ansi_port.c nr_micro_shell.c
  group BOS/ThirdParty/FlexibleButton
    ../bos/thirdparty/FlexibleButton/: flexible_button.c
  group BOS/ThirdParty/UGUI
    ../bos/thirdparty/UGUI/: ugui.c
  group BOS/ThirdParty/CmBacktrace
    ../bos/thirdparty/CmBacktrace/: cm_backtrace.c
  group BOS/ThirdParty/qpn
    ../bos/thirdparty/qpn/src/: qepn.c qfn.c qstamp.c qvn.c
  group BOS/Examples/qpn
    ../Examples/qpn/: blinky.c blinky.h bsp.c bsp.h
  group BOS/Algorithm
    ../bos/algorithm/: algo_base64.c algo_sort.c
  group BOS/Config
    ../bos/config/: b_config.h b_device_list.h
software components: CMSIS:CORE 4.3.0
